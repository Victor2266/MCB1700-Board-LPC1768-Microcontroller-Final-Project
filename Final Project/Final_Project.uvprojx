# Keil uVision project Final_Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FinalProject
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USBAudio
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\USBAudio\DMA.sct
  group Source Group 1
    ./: main.c Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c type.h KBD.c KBD.h MainMenu.c osObjects.h GameScript.h MainMenu.h GameScript.c
    ./USBAudio/: Abstract.txt adcuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c
    ./Images/: blueFlower.c colorful-BG.c darkerBG.c gallery.c gameIcon.c musical-note.c sword.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 1.0.0
